# IAR project tiva.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Software/Interface; Software/Common; Software/Controller
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tiva.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Software/App/Main
    Software/App/Main/: main.c
  group Software/Common
    Software/Common/: Common_Datatype.h Common_Macros.h
  group Software/Controller
    Software/Controller/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h TM4C123GH6PM.h
  group Software/Driver/ADC
    Software/Driver/ADC/: ADC_Driver.c ADC_Driver.h
  group Software/Driver/GPIO
    Software/Driver/GPIO/: GPIOdriver.c GPIOdriver.h
  group Software/Driver/LCD
    Software/Driver/LCD/: LCD.c LCD.h
  group Software/Driver/Timer
    Software/Driver/Timer/: Timer.c Timer.h
  group Software/Interface
    Software/Interface/: ADC_Driver_Interface.h GPIO_Driver_Interface.h LCD_Interface.h Timer_Interface.h
