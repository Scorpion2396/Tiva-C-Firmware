# IAR project tiva.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: Source/Interface; Source/Common; Source/CMSIS; Source/BSP; Source/MIRTOS
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tiva.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Source/App/Main
    Source/App/Main/: main.c
  group Source/BSP
    Source/BSP/: bsp.c bsp.h
  group Source/CMSIS
    Source/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h TM4C123GH6PM.h
  group Source/Common
    Source/Common/: Common_Const.h Common_Datatype.h Common_Macros.h
  group Source/Driver/ADC
    Source/Driver/ADC/: ADC_Driver.c ADC_Driver.h
  group Source/Driver/CAN
    Source/Driver/CAN/: CAN_Driver.c CAN_Driver.h
  group Source/Driver/GPIO
    Source/Driver/GPIO/: GPIOdriver.c GPIOdriver.h
  group Source/Driver/I2C
    Source/Driver/I2C/: I2C.c I2C.h
  group Source/Driver/LCD
    Source/Driver/LCD/: LCD.c LCD.h
  group Source/Driver/SPI
    Source/Driver/SPI/: SPI.c SPI.h
  group Source/Driver/TIMER
    Source/Driver/Timer/: Timer.c Timer.h timercnter.c timercnter.h
  group Source/Driver/UART
    Source/Driver/UART/: UART.c UART.h
  group Source/Interface
    Source/Interface/: ADC_Driver_Interface.h CAN_Interface.h DS3231_Interface.h GPIO_Driver_Interface.h I2C_Interface.h LCD_Interface.h MCP3208_Interface.h SPI_Interface.h SSD1306_Interface.h Timer_Interface.h timercnter_interface.h UART_Interface.h
  group Source/Middleware/MCP3208
    Source/Middleware/MCP3208/: MCP3208.c MCP3208.h
  group Source/Middleware/OLED_SSD1306
    Source/Middleware/OLED_SSD1306/: SSD1306.c SSD1306.h
  group Source/Middleware/RTC_DS3231
    Source/Middleware/RTC_DS3231/: DS3231.c DS3231.h
